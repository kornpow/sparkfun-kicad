# Repository kornpow/sparkfun-kicad

## EAGLE design SparkFun_QwiicBus_Endpoint/EAGLE/SparkFun_QwiicBus_Endpoint.brd

Parts:
0-1: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
C1, C2: 0.1uF; 0603
C3, C4: 1.0uF; 0603
D11: RED; LED-0603
FD1, FD2, FD3, FD4: FIDUCIALUFIDUCIAL; FIDUCIAL-MICRO
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
GND: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
H1, H2, H3, H4: STAND-OFF
I2C: JUMPER-SMT_3_2-NC_TRACE_SILK; SMT-JUMPER_3_2-NC_TRACE_SILK
J1, J2: QWIIC; JST04_1MM_RA
J3: RJ45; RJ45-8
J4, J6, J8: CONN_041X04_NO_SILK; 1X04_NO_SILK
J5: CONN_01PTH_NO_SILK_YES_STOP; 1X01_NO_SILK
LOGO1: OSHW-LOGOM; OSHW-LOGO-M
LOGO2: REVISION
LOGO3: QWIIC_LOGO_4MM; QWIIC_4MM
LOGO4: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO5: SFE_LOGO_FLAME.1_INCH; SFE_LOGO_FLAME_.1
PWR: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
R1, R3, R4, R6: 390; 0603
R2, R5: 100; 0603
R7, R8: 4.7k; 0603
R11: 1k; 0603
U1: PCA9615; TSSOP10
VCC1: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK

Connections:
DSCL_N: J3.1, R2.1, R3.2, U1.6 (DSCL-)
DSCL_P: J3.2, R1.1, R2.2, U1.7 (DSCL+)
DSDA_N: J3.7, R5.1, R6.2, U1.9 (DSDA-)
DSDA_P: J3.8, R4.1, R5.2, U1.8 (DSDA+)
EN: J5.1, U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, GND.1, J1.1, J2.1, J4.1, J6.1, J8.1, PWR.1, R3.1, R6.1, U1.5 (GND)
GRN_N: J3.6, J4.3, J6.3
GRN_P: J3.3, J4.4, J6.4
unnamed: J3.4, VCC1.2
unnamed: GND.2, J3.5
unnamed: I2C.1, R8.2
unnamed: I2C.3, R7.2
unnamed: D11.C, R11.1
unnamed: PWR.2, R11.2
SCL: J1.4, J2.4, J8.4, R7.1, U1.4 (SCL)
SDA: J1.3, J2.3, J8.3, R8.1, U1.2 (SDA)
VCC: 0-1.2, C1.1, C3.1, D11.A, I2C.2, J1.2, J2.2, J8.2, U1.1 (VDDA)
VCC_1: 0-1.1, C2.1, C4.1, J4.2, J6.2, R1.2, R4.2, U1.10 (VDDB), VCC1.1

Notes on the sheet:
Joel Bartlett
I2C -> Differential I2C
Qwiic Connectors
v11
I2C = I2C Pullups Closed by Default
Headers
I2C Pullups
RJ-45 Connector
Differential I2C Termination Resistors
Cut traces on VCC1 and GND jumpers to disconnect VCC1 and GND from cable.
Andy England
Cut the PWR jumper to disable the PWR LED
VIN: 3.0-5.5V
VCC: I2C-bus side power supply (2.3V-5.5V) VCC1: Differential side power supply (3.0V-5.5V)
Cut 0-1 Jumper to provide separate voltage to VCC1 and VCC (VCC0)
Depending on load and distance requirements, there are several different ways to power the Midpoint/Endpoint combo. --- The default option powers the entire system using 3.3V, in this configuration, the BP jumper is closed and both sides of the PSEL jumper are open. --- To power the VCC_1 rail with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

Board: 2 copper layers, 44.5 x 25.4 mm, 76 parts (23 on the bottom side), 18 nets.

Other parts of the board:
U$1: I2C
U$2, U$29: GRN0
U$3, U$4, U$5, U$6, U$13, U$33, U$34: #GND#0
U$7, U$8: #3V3#0
U$9, U$15: #SDA#0
U$10, U$16: #SCL#0
U$11, U$17: #EN#0
U$12: #VDDA#0
U$14, U$18: #GND2#0
U$19, U$22: #GRNW#0
U$20, U$21, U$31, U$32: #VCC1#0
U$23, U$28: QWIICBUS#WORKING#LOGO#JPG
U$24, U$30: #VCC2#0
U$25: 0#10
U$26, U$35: ENDPOINT0
U$27: PWR0

## Commit log

2024-05-28 add gitignore
2024-05-28 copy and convert QwiicBus EndPoint
    From GitHub Repo:sparkfun/SparkFun_Differential_I2C_Breakout_PCA9615_Qwiic@49600312278fdb7ca43ea27716a2875781affc55
2024-05-30 copy and convert HX711 LoadCell
    From GitHub Repo:sparkfun/HX711-Load-Cell-Amplifier/tree/V_1.1
2024-05-30 ignore backup files
2024-05-30 copy and convert Qwiic_Thermocouple_Amplifier
    From GitHub Repo:sparkfun/Qwiic_Thermocouple_Amplifer@17363932880175787ef9ed4d1c1540a5647180c7
2024-05-30 copy and convert SparkFun_Qwiic_RFID_Tag_ST25DV64KC
    From GitHub Repo:sparkfun/SparkFun_Qwiic_RFID_Tag_ST25DV64KC@3769d5a44c71c0aa3b8b94126b3d8e426dc7eeb4

Notices in the files:
parts and their libraries:
SparkFun-Aesthetics: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
